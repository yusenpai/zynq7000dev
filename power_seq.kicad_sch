File: power_seq.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: update
Other:
- note added: "0.8A"
- note added: "Audio CODEC"
